# Keil uVision project idd_fall15_hw2_echiou_uchord.uvproj, settings and files
target mbed FRDM-KL25Z (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: idd_fall15_hw2_echiou_uchord
  AfterMake: fromelf --bin -o build\idd_fall15_hw2_echiou_uchord_KL25Z.bin build\idd_fall15_hw2_echiou_uchord.axf
  c flags: Optim=1
  c define: TARGET_FF_ARDUINO,  TARGET_KLXX,  MBED_BUILD_TIMESTAMP=1445995309.94,  TARGET_KL25Z,  TARGET_CORTEX_M,  TARGET_M0P,  TARGET_Freescale,  __MBED__=1,  __CORTEX_M0PLUS,  TOOLCHAIN_ARM,  TOOLCHAIN_ARM_STD,  ARM_MATH_CM0PLUS,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  DebounceIn;  mbed;  mbed/TARGET_KL25Z;  mbed/TARGET_KL25Z/TARGET_Freescale;  mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX;  mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z;  mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD;
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  link misc: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/mbed_overrides.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/startup_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/system_MKL25Z4.o
            
              mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp
